# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157A_M4 ST STM32MP157A_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RT_USING_DLIBC; CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; STM32MP157Axx; __LOG_TRACE_IO_; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\libraries\STM32MPxx_HAL\CMSIS\Core\Include; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\dlib; board\ports\OpenAMP\open-amp\lib\include; ..\..\..\components\libc\compilers\common; board\ports\OpenAMP\virtual_driver; board\CubeMX_Config\CM4\Inc; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; board\ports; board\ports\OpenAMP\libmetal\lib\include; ..\libraries\STM32MPxx_HAL\CMSIS\Include; board\ports\OpenAMP; ..\..\..\include; ..\libraries\STM32MPxx_HAL\CMSIS\Device\ST\STM32MP1xx\Include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; applications; ..\libraries\STM32MPxx_HAL\STM32MP1xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.bin
  ILINK.IlinkOutputFile: RT-Thread-STM32MP1_CM4.elf
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group dlib
    ../../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    board/CubeMX_Config/CM4/Src/: openamp.c rsc_table.c openamp_log.c mbox_ipcc.c stm32mp1xx_hal_msp.c
    board/ports/OpenAMP/open-amp/lib/virtio/: virtqueue.c virtio.c
    board/ports/OpenAMP/libmetal/lib/system/generic/: generic_shmem.c generic_device.c condition.c generic_irq.c generic_init.c generic_time.c generic_io.c
    board/ports/: drv_nand.c drv_pwr.c drv_rcc.c drv_pmic.c drv_rs485.c drv_exti.c drv_lptim.c
    board/ports/OpenAMP/virtual_driver/: virt_uart.c
    board/ports/OpenAMP/: drv_openamp.c
    board/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/ports/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c remoteproc.c rsc_table_parser.c elf_loader.c
    board/ports/OpenAMP/libmetal/lib/: shmem.c log.c init.c st_device.c version.c io.c dma.c
    board/ports/OpenAMP/open-amp/lib/rpmsg/: rpmsg_virtio.c rpmsg.c
    board/: board.c
    ../libraries/STM32MPxx_HAL/CMSIS/Device/ST/STM32MP1xx/Source/Templates/iar/: startup_stm32mp15xx.s
    board/ports/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_common.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32MPxx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_lptim.c
